## arch/arm/configs/apq8084_sec_userdebug_defconfig
```kconfig
# CONFIG_SEC_RESTRICT_ROOTING is not set
# CONFIG_IKCONFIG is not set
# CONFIG_IKCONFIG_PROC is not set
```
